# Keil uVision project M800.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC11U37/401 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: BootLoader_2018 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE #L
  AfterMake: fromelf.exe --bincombined --output "$L@L.bin" "$L@L.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORE_M0,PMW3360, P502,M_FW_UPDATE
  c misc: --c99
  c include: .\Inc
  memory RVCT4: ROM 0x0 size 0x3fff
  memory RVCT9: RAM 0x10000100 size 0x1e00
  memory RVCT10: RAM 0x20004000 size 0x800
  group Main
    ./: startup_LPC11Uxx.s
    ./Src/: core_cm0.c gpio.c hiduser.c I2c.c Keytbl.c main.c pmu.c ssp.c system_LPC11Uxx.c Systick.c timer16.c timer32.c uart.c usbcore.c usbdesc.c usbhw.c usbuser.c wdt.c Pixart_Sensor.c srom.c Mouse.c Wheel.c eepromAPI.c bod.c
  group Sourece
    ./Src/: WFLASH.c Source.c
