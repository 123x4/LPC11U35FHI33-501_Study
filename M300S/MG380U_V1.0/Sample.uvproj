# Keil uVision project Sample.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC11U37/401 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Sample +hex
  AfterMake: G:\exe\Keil_v5\ARM\BIN\ElfDwT.exe #L
  AfterMake: G:\exe\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ./Output/@L.bin  ./Output/@L.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\inc;.\inc\Led_Effect_H
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0xc000
  memory RVCT9: RAM 0x10000100 size 0x1f00
  memory RVCT10: RAM 0x20004000 size 0x800
  group Main
    ./src/: Main.c
  group Source
    ./src/: GPIO.c I2C.c OSC.c SPI.c Timer.c UART.c ADC.c gtech_flash.c operation_flash.c pc_communicate.c macro.c keydef.c suspend.c wnDrv_Pmu.c eeprom.c WWDT.c
  group USB
    ./src/: hiduser.c usbdesc.c usbhw.c usbuser.c usb.c usbcore.c
  group Startup
    ./src/: core_cm0.c startup_LPC11Uxx.s
  group App
    ./src/: device.c
    ./app/: scroll.c custom.c optical_3325.c
  group Led_Effect_Group
    ./Led_Effect_Gruop_Code/: test.c Production_line_test.c ram_malloc.c breath.c color_cycle.c led2.c reaction.c static.c
    ./app/: button.c
