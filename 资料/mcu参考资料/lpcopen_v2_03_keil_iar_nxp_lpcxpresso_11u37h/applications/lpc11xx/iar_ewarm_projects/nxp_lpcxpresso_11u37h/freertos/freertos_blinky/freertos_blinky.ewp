# IAR project freertos_blinky.ewp, settings and files
configuration iflash_nxp_lpcxpresso_11u37h (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U37HFBD64_401 NXP LPC11U37HFBD64_401
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pe161, Pa050, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11uxx; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\..\software\freertos\freertoslpc; ..\..\..\..\examples\freertos\freertos_blinky
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M0
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11uxx; ..\..\..\..\examples\freertos\freertos_blinky
  OBJCOPY.OOCOutputFile: freertos_blinky.bin
  ILINK.IlinkOutputFile: freertos_blinky.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../../examples/freertos/freertos_blinky/: freertos_blinky.c
    ../../../../startup_code/: iar_startup_lpc11xx.s sysinit.c
  group FreeRTOS
    ../../../../../../software/freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_2.c
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_11xx/nxp_lpcxpresso_11u37h/iar_output/Exe/: board_nxp_lpcxpresso_11u37h.a
    ../../../../../../software/lpc_core/lpc_chip/chip_11xx/iar_output/chip_11uxx_lib/Exe/: chip_11uxx_lib.a
