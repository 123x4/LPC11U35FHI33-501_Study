# IAR project periph_grouped_int.ewp, settings and files
configuration iflash_nxp_lpcxpresso_11u37h (ARM)
  General.OGChipSelectEditMenu: LPC11U37HFBD64_401 NXP LPC11U37HFBD64_401
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11uxx; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11uxx
  OBJCOPY.OOCOutputFile: periph_grouped_int.bin
  ILINK.IlinkOutputFile: periph_grouped_int.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../../examples/periph/periph_grouped_int/: grouped_int.c
    ../../../../startup_code/: iar_startup_lpc11xx.s sysinit.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_11xx/nxp_lpcxpresso_11u37h/iar_output/Exe/: board_nxp_lpcxpresso_11u37h.a
    ../../../../../../software/lpc_core/lpc_chip/chip_11xx/iar_output/chip_11uxx_lib/Exe/: chip_11uxx_lib.a
