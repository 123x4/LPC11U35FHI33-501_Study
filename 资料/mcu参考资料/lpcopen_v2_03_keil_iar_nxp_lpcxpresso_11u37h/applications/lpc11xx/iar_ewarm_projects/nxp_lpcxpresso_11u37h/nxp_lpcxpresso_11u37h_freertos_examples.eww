<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\freertos\freertos_blinky\freertos_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h\lib_lpc_board_nxp_lpcxpresso_11u37h.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\lib_lpc_chip_11uxx.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All_libs_and_Examples</name>
      <member>
        <project>lib_lpc_chip_11uxx</project>
        <configuration>chip_11uxx_lib</configuration>
      </member>
      <member>
        <project>lib_lpc_board_nxp_lpcxpresso_11u37h</project>
        <configuration>nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>freertos_blinky</project>
        <configuration>iflash_nxp_lpcxpresso_11u37h</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all_libs</name>
      <member>
        <project>lib_lpc_chip_11uxx</project>
        <configuration>chip_11uxx_lib</configuration>
      </member>
      <member>
        <project>lib_lpc_board_nxp_lpcxpresso_11u37h</project>
        <configuration>nxp_lpcxpresso_11u37h</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


