<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h\lib_lpc_board_nxp_lpcxpresso_11u37h.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\lib_lpc_chip_11uxx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_adc\periph_adc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_blinky\periph_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_bod\periph_bod.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_clkout\periph_clkout.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_grouped_int\periph_grouped_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_i2c\periph_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_pinint\periph_pinint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_ssp\periph_ssp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_uart\periph_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_watchdog\periph_watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All_libs_and_Examples</name>
      <member>
        <project>lib_lpc_board_nxp_lpcxpresso_11u37h</project>
        <configuration>nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>lib_lpc_chip_11uxx</project>
        <configuration>chip_11uxx_lib</configuration>
      </member>
      <member>
        <project>periph_adc</project>
        <configuration>iflash_nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>periph_bod</project>
        <configuration>iflash_nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>periph_clkout</project>
        <configuration>iflash_nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>periph_grouped_int</project>
        <configuration>iflash_nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>iflash_nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>periph_pinint</project>
        <configuration>iflash_nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>iflash_nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>iflash_nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>iflash_nxp_lpcxpresso_11u37h</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all_libs</name>
      <member>
        <project>lib_lpc_board_nxp_lpcxpresso_11u37h</project>
        <configuration>nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>lib_lpc_chip_11uxx</project>
        <configuration>chip_11uxx_lib</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


