<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\lib_lpc_chip_11uxx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h\lib_lpc_board_nxp_lpcxpresso_11u37h.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom\usbd_rom_cdc_uart\usbd_rom_cdc_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom\usbd_rom_cdc\usbd_rom_cdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom\usbd_rom_composite\usbd_rom_composite.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom\usbd_rom_hid_generic\usbd_rom_hid_generic.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom\usbd_rom_hid_i2c\usbd_rom_hid_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom\usbd_rom_hid_keyboard\usbd_rom_hid_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom\usbd_rom_hid_mouse\usbd_rom_hid_mouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom\usbd_rom_libusb\usbd_rom_libusb.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All_libs_and_Examples</name>
      <member>
        <project>lib_lpc_chip_11uxx</project>
        <configuration>chip_11uxx_lib</configuration>
      </member>
      <member>
        <project>lib_lpc_board_nxp_lpcxpresso_11u37h</project>
        <configuration>nxp_lpcxpresso_11u37h</configuration>
      </member>
      <member>
        <project>usbd_rom_cdc</project>
        <configuration>iflash_nxp_lpcxpresso_11u14</configuration>
      </member>
      <member>
        <project>usbd_rom_cdc_uart</project>
        <configuration>iflash_nxp_lpcxpresso_11u37</configuration>
      </member>
      <member>
        <project>usbd_rom_composite</project>
        <configuration>iflash_nxp_lpcxpresso_11u37</configuration>
      </member>
      <member>
        <project>usbd_rom_hid_generic</project>
        <configuration>iflash_nxp_lpcxpresso_11u37</configuration>
      </member>
      <member>
        <project>usbd_rom_hid_i2c</project>
        <configuration>iflash_nxp_lpcxpresso_11u37</configuration>
      </member>
      <member>
        <project>usbd_rom_hid_keyboard</project>
        <configuration>iflash_nxp_lpcxpresso_11u37</configuration>
      </member>
      <member>
        <project>usbd_rom_hid_mouse</project>
        <configuration>iflash_nxp_lpcxpresso_11u37</configuration>
      </member>
      <member>
        <project>usbd_rom_libusb</project>
        <configuration>iflash_nxp_lpcxpresso_11u14</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


