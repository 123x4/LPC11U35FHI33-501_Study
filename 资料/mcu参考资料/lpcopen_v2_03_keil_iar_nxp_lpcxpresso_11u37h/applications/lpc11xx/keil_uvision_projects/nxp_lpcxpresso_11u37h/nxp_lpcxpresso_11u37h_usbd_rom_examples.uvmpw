<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\lib_lpc_chip_11uxx.uvproj</PathAndName>
    <NodeIsActive>1</NodeIsActive>
  </project>

  <project>
    <PathAndName>..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h\lib_lpc_board_nxp_lpcxpresso_11u37h.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_cdc\usbd_rom_cdc.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_hid_generic\usbd_rom_hid_generic.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_hid_i2c\usbd_rom_hid_i2c.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_hid_keyboard\usbd_rom_hid_keyboard.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_hid_mouse\usbd_rom_hid_mouse.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_cdc_uart\usbd_rom_cdc_uart.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_composite\usbd_rom_composite.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_libusb\usbd_rom_libusb.uvproj</PathAndName>
  </project>

</ProjectWorkspace>
