# Keil uVision project usbd_rom_hid_i2c.uvproj, settings and files
target iflash_lpcxpresso_11u37h (ARM-ADS)
  device: LPC11U37/501 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: usbd_rom_hid_i2c +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c misc: --gnu --c99
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11uxx;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h;..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom;..\..\..\..\examples\usbd_rom\usbd_rom_hid_i2c;..\..\..\..\..\..\software\lpcusbsio
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11uxx
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group example
    ../../../../startup_code/: keil_startup_lpc11xx.s sysinit.c
    ../../../../examples/usbd_rom/usbd_rom_hid_i2c/: hid_desc.c hid_i2c.c hid_main.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_11xx/keil_output/chip_11uxx_lib/: chip_11uxx_lib.lib
    ../../../../../../software/lpc_core/lpc_board/boards_11xx/nxp_lpcxpresso_11u37h/keil_output/: board_nxp_lpcxpresso_11u37h.lib
