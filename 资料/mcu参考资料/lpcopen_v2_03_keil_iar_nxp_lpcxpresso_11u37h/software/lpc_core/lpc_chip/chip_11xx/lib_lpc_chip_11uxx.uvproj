# Keil uVision project lib_lpc_chip_11uxx.uvproj, settings and files
target chip_11uxx_lib (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: chip_11uxx_lib (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\software\lpc_core\lpc_chip\chip_11xx;..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\software\CMSIS;.\config_11uxx
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group csp
    ../chip_common/: ring_buffer.c
    ./: acmp_11xx.c adc_11xx.c clock_11xx.c dac_11xx.c i2c_11xx.c i2cm_11xx.c iocon_11xx.c ssp_11xx.c sysctl_11xx.c timer_11xx.c uart_11xx.c wwdt_11xx.c sysinit_11xx.c chip_11xx.c adc_1125.c gpio_11xx_1.c gpio_11xx_2.c gpiogroup_11xx.c pinint_11xx.c pmu_11xx.c
