# Keil uVision project lib_lpc_board_nxp_lpcxpresso_11u37h.uvproj, settings and files
target nxp_lpcxpresso_11u37h (ARM-ADS)
  device: LPC11U37/501 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: board_nxp_lpcxpresso_11u37h (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\CMSIS;..\..\..\lpc_chip\chip_11xx;..\..\..\lpc_chip\chip_11xx\config_11uxx;..\..\..\lpc_chip\chip_common;..\nxp_lpcxpresso_11u37h;..\..\board_common
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group board_nxp_lpcxpresso_11u37h
    ./: board.c board_sysinit.c
    ../../board_common/: uda1380.c
