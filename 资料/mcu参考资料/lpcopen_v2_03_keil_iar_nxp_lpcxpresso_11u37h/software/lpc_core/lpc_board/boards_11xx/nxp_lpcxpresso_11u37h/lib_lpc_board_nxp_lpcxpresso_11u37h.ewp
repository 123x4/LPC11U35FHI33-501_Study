# IAR project lib_lpc_board_nxp_lpcxpresso_11u37h.ewp, settings and files
configuration nxp_lpcxpresso_11u37h (ARM)
  General.OGChipSelectEditMenu: LPC11U37HFBD64_401 NXP LPC11U37HFBD64_401
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\lpc_chip\chip_common; ..\..\..\lpc_chip\chip_11xx; ..\..\..\lpc_chip\chip_11xx\config_11uxx; ..\..\..\lpc_board\board_common; $PROJ_DIR$; ..\..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group board_nxp_lpcxpresso_11u37h
    ./: board.c board_sysinit.c
    ../../board_common/: uda1380.c
