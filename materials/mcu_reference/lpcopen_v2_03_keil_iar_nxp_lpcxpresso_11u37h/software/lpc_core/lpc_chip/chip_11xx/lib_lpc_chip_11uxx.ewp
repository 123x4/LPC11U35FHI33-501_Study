# IAR project lib_lpc_chip_11uxx.ewp, settings and files
configuration chip_11uxx_lib (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U14FBD48_201 NXP LPC11U14FBD48_201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; config_11uxx; ../chip_common; ../../../CMSIS/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_lpc_chip_110x.out
  group csp
    ./: acmp_11xx.c adc_1125.c adc_11xx.c chip_11xx.c clock_11xx.c dac_11xx.c gpio_11xx_1.c gpio_11xx_2.c gpiogroup_11xx.c i2c_11xx.c i2cm_11xx.c iocon_11xx.c pinint_11xx.c pmu_11xx.c ssp_11xx.c sysctl_11xx.c sysinit_11xx.c timer_11xx.c uart_11xx.c wwdt_11xx.c
    ../chip_common/: ring_buffer.c
