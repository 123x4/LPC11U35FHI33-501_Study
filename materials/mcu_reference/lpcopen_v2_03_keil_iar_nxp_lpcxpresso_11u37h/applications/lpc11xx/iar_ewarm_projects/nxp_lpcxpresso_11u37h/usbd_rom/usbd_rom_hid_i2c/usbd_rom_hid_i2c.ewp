# IAR project usbd_rom_hid_i2c.ewp, settings and files
configuration iflash_nxp_lpcxpresso_11u37 (ARM)
  General.OGChipSelectEditMenu: LPC11U37HFBD64_401 NXP LPC11U37HFBD64_401
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11uxx; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom; ..\..\..\..\..\..\software\lpcusbsio
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11uxx
  OBJCOPY.OOCOutputFile: usbd_rom_hid_i2c.bin
  ILINK.IlinkOutputFile: usbd_rom_hid_i2c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../../examples/usbd_rom/usbd_rom_hid_i2c/: hid_desc.c hid_i2c.c hid_main.c
    ../../../../startup_code/: iar_startup_lpc11xx.s sysinit.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_11xx/nxp_lpcxpresso_11u37h/iar_output/Exe/: board_nxp_lpcxpresso_11u37h.a
    ../../../../../../software/lpc_core/lpc_chip/chip_11xx/iar_output/chip_11uxx_lib/Exe/: chip_11uxx_lib.a
