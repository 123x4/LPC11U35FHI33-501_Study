# Keil uVision project freerots_blinky.uvproj, settings and files
target iflash_nxp_lpcxpresso_11u37h (ARM-ADS)
  device: LPC11U37/501 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: freertos_blinky
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11uxx;..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM0;..\..\..\..\..\..\software\freertos\freertoslpc;..\..\..\..\examples\freertos\freertos_blinky
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11uxx
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group example
    ../../../../startup_code/: sysinit.c
    ../../../../examples/freertos/startup_code/: keil_freertos_startup_lpc11xx.s
    ../../../../examples/freertos/freertos_blinky/: freertos_blinky.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_11xx/keil_output/chip_11uxx_lib/: chip_11uxx_lib.lib
    ../../../../../../software/lpc_core/lpc_board/boards_11xx/nxp_lpcxpresso_11u37h/keil_output/: board_nxp_lpcxpresso_11u37h.lib
  group FreeRTOS
    ../../../../../../software/freertos/freertos/Source/: timers.c tasks.c queue.c list.c croutine.c
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
