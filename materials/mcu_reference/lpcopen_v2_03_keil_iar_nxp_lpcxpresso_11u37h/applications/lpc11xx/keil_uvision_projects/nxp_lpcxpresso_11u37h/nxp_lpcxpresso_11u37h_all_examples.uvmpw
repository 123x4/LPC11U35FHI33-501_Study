<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\lib_lpc_chip_11uxx.uvproj</PathAndName>
    <NodeIsActive>1</NodeIsActive>
  </project>

  <project>
    <PathAndName>..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11u37h\lib_lpc_board_nxp_lpcxpresso_11u37h.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\periph\periph_adc\periph_adc.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\periph\periph_blinky\periph_blinky.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\periph\periph_bod\periph_bod.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\periph\periph_clkout\periph_clkout.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\periph\periph_grouped_int\periph_grouped_int.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\periph\periph_i2c\periph_i2c.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\periph\periph_pinint\periph_pinint.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\periph\periph_ssp\periph_ssp.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\periph\periph_uart\periph_uart.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\periph\periph_watchdog\periph_watchdog.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\freertos\freertos_blinky\freerots_blinky.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_cdc\usbd_rom_cdc.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_hid_generic\usbd_rom_hid_generic.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_hid_keyboard\usbd_rom_hid_keyboard.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_hid_mouse\usbd_rom_hid_mouse.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_cdc_uart\usbd_rom_cdc_uart.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>.\usbd_rom\usbd_rom_composite\usbd_rom_composite.uvproj</PathAndName>
  </project>

</ProjectWorkspace>
